# Keil uVision project Libs.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Libs
  c flags: Optim=1
  c include: .\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s my.c
    ./src/: PID_v1.cpp lookup_v1.cpp mid_lookup_v1.cpp avgfilter.cpp mid_avgfilter.cpp
